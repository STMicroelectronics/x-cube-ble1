# Keil uVision project Project.uvprojx, settings and files
target STM32L476RG_NUCLEO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: DMA_LP_Profiles +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER,__DMA_LP__
  c include: ../Inc;../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Inc;../../../../../Middlewares/ST/BlueNRG-MS/includes;../../../../../Middlewares/ST/BlueNRG-MS/utils;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1;../../../../../Middlewares/ST/TimerServer/inc;../../../../../Middlewares/ST/TimerServer/STM32xx_HAL_TimerServer_Drivers/inc;../../../../../Middlewares/ST/LowPowerManager/Inc;../../../../../Middlewares/ST/BlueNRG-MS/STM32L4xx_HAL_BlueNRG_Drivers/inc;../STM32xx_HAL_APP_Drivers/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/HAL_APP_Drivers
    ../STM32xx_HAL_APP_Drivers/src/: stm32xx_hal_app_rtc.c
  group Application/User
    ../Src/: gp_timer.c bps_profile_application.c fmt_profile_application.c anc_profile_application.c ans_profile_application.c pac_profile_application.c hci_tl_interface.c cube_hal_l4.c pm_profile_application.c stm32l4xx_hal_msp.c profile_application.c gs_profile_application.c pr_profile_application.c hci_tl.c hid_profile_application.c htm_profile_application.c ts_profile_application.c low_power_conf_l4.c stm32l4xx_it.c hrm_profile_application.c main.c tc_profile_application.c fml_profile_application.c
  group Doc
    ../: readme.md
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble_dma_lp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_spi.c stm32l4xx_hal_adc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c
  group Middlewares/BlueNRG-MS/HAL_Drivers
    ../../../../../Middlewares/ST/BlueNRG-MS/STM32L4xx_HAL_BlueNRG_Drivers/src/: stm32l4xx_hal_bluenrg_syscfg.c stm32l4xx_hal_bluenrg_gpio.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gatt_aci.c bluenrg_l2cap_aci.c bluenrg_hal_aci.c bluenrg_gap_aci.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Template
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/ANC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/alert_notification_client/: alertNotification_Client.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/ANS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/alert_notification_server/: alertNotification_Server.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/BLE_Profile
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/ble_profile/: profile.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/BPS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/blood_pressure_sensor/: blood_pressure_sensor.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/FML
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Find_Me_Locator/: findme_locator.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/FMT
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Find_Me_Target/: findme_target.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/GS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/glucose_sensor/: glucose_sensor.c glucose_racp.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/HID
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/hid_device/: hid_device_sm_services.c hid_device.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/HR
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/heart_rate/: heart_rate.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/HT
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Health_Thermometer/: health_thermometer.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/PAC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Phone_Alert_Client/: phoneAlert_Client.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/PM
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/proximity_monitor/: proximity_monitor.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/PR
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/proximity_reporter/: proximity_reporter.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/TC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/time_client/: time_client.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/TS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/time_server/: time_server.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Utils/: timer.c
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/LPM
    ../../../../../Middlewares/ST/LowPowerManager/Src/: stm32xx_lpm.c
  group Middlewares/TimerServer
    ../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
software components: CMSIS:CORE 5.4.0
